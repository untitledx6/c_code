# Keil uVision project terminal.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT8xC5122 Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0x7FFF) CLOCK(16000000) MODP2
  output: terminal +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Commands.c Commands.h Helper.h Helper.c main.c STC15F2K60S2.h Terminal.c Terminal.h Uart.c Uart.h
